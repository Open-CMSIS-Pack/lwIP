# Keil uVision project httpd.uvprojx, settings and files
target V2M-MPS2 (6210000::V6.21::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.1
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: httpd
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: LWIP_HTTPD_FILE_EXTENSION
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  group Source
    ./: main.c httpd.c fs.c
  group Documentation
    ./: abstract.txt
software components: CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:Ethernet:LAN9220 1.2.0, Device:Startup 1.2.0, Network:API 2.3.0, Network:CORE 2.3.0, Network:Driver:Ethernet 2.3.0, Network:Interface:Ethernet 2.3.0, Network:RTOS 2.3.0
