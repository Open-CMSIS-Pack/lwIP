# Keil uVision project httpd.uvprojx, settings and files
target MCBSTM32F200 V1.1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: httpd
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c httpd.c fs.c
  group Documentation
    ./: abstract.txt
target MCBSTM32F200 V1.2 (6160000::V6.16::ARMCLANG)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: as above
  output: httpd
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:SRAM 1.2.7, Device:Startup 2.2.1, Network:API 2.2.0, Network:CORE 2.2.0, Network:Driver:Ethernet 2.2.0, Network:Interface:Ethernet 2.2.0, Network:RTOS 2.2.0
